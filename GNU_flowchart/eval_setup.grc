options:
  parameters:
    author: UCLouvain
    generate_options: qt_gui
    id: eval_limesdr
    output_language: python
    title: LELEC2102 - Decode SDR
  states: {}

blocks:
- name: AGC_on
  id: variable
  parameters:
    comment: |-
      agc_on (défaut: 1) - Active/désactive l'AGC

      1 : AGC automatique activé
      0 : Gain manuel fixe
    value: '0'
  states: {}
- name: AGC_target
  id: variable
  parameters:
    comment: |-
      (défaut: 3) - Niveau cible pour l'AGC automatique
      Fonctionnalité désactivée pour l'instant

      0 : -21 dBFS (le plus sensible)
      1 : -24 dBFS
      2 : -27 dBFS
      3 : -30 dBFS
      4 : -33 dBFS
      5 : -36 dBFS
      6 : -39 dBFS
      7 : -42 dBFS (le moins sensible)
    value: '3'
  states: {}
- name: Enable_detection
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: Print_metrics
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: Print_payload
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: center_freq_hz
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: chunk_bytes
  id: variable
  parameters:
    comment: |-
      8192 = default value
      dont go further than 16384
    value: 8192//8
  states: {}
- name: crc_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: detect_threshold_entry
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: detect_threshold_entry
  id: variable_qtgui_entry
  parameters:
    label: Detection Threshold
    type: real
    value: '1e-3'
  states: {}
- name: fdev
  id: variable
  parameters:
    value: data_rate/4
  states: {}
- name: hdr_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: manual_gain
  id: variable
  parameters:
    comment: |-
      manual_gain (défaut: 10) - Gain fixe en mode manuel

      0 : 0 dB (gain minimum)
      23 : 69 dB (gain maximum)
      Chaque unité = 3 dB de gain
    value: '6'
  states: {}
- name: noiseQuery
  id: variable_qtgui_push_button
  parameters:
    label: Noise estimation query
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: hdr_len+payload_len+crc_len
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '100'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '73'
    value: '10'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    comment: Don't touch this, it's set with sample_rate_register_config variable
    value: 4000000/sample_rate_register_config
  states: {}
- name: sample_rate_register_config
  id: variable
  parameters:
    comment: |-
      Defines the RXDFE register value:
      1	4 000 000 éch/s	flux le plus dense, aucun mot bourrage
      2	2 000 000 éch/s	un mot sur deux transmis, 50 % de bourrage
      3	1 333 333 éch/s	(valeur actuelle, 0x83)
      4	1 000 000 éch/s	
      5	800 000 éch/s	
      6	666 667 éch/s	
      7	571 429 éch/s	débit mini

      cette valeur définit directement le samp_rate
      recommended value : 3
    value: '5'
  states: {}
- name: tx_power
  id: variable_qtgui_entry
  parameters:
    label: TX power used (no impact, just for logging)
    type: int
    value: '0'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    maximum: '2048'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4096'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: chunk_bytes//4
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np

      class iq_unpack_cc(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="iq_unpack_cc",
                  in_sig=[(np.uint8, 16384)],      # vecteur de 16384 octets
                  out_sig=[(np.complex64, 4096)]   # vecteur de 4096 complexes
              )

          def work(self, input_items, output_items):
              data = input_items[0]             # vecteur uint8[16384]
              out  = output_items[0]            # vecteur complex64[4096]
              for i in range(4096):
                  w = (data[4*i]<<24)|(data[4*i+1]<<16)|(data[4*i+2]<<8)|data[4*i+3]
                  raw_i = (w>>16)&0x3FFF;  raw_q = w&0x3FFF
                  if raw_i & 0x2000: raw_i |= ~0x3FFF
                  if raw_q & 0x2000: raw_q |= ~0x3FFF
                  out[i] = complex(raw_i, raw_q)
              return 4096  # on a produit 4096 samples
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Affiche les N premiers octets reçus en hexadécimal (style hexdump).\n    \"\"\"\n\n    def __init__(self, nbytes=256):\n        gr.sync_block.__init__(self,\n            name    = \"udp_hexdump\",\n            in_sig  = [np.uint8],   # flux d'octets\n            out_sig = None)         # on ne relaie rien\n\n        self.limit = nbytes     # nombre d'octets à afficher\n        self.count = 0\n\n    def work(self, input_items, output_items):\n        data = input_items[0]\n\n        for b in data:\n            if self.count >= self.limit:\n                continue            # on a déjà tout imprimé\n            if self.count % 16 == 0:\n                # nouvelle ligne avec l'offset\n                print(f\"{self.count:08x}  \", end='', flush=False)\n            print(f\"{int(b):02x} \", end='', flush=False)\n            self.count += 1\n            if self.count % 16 == 0:\n                print()             # retour ligne\n        return len(data)\n\n"
    nbytes: '10000000000000000000000000'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass iq13_to_c(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"iq13_to_c_safe\",\n            in_sig=[np.uint8],\n            out_sig=[np.complex64])\n        self.buf = bytearray()\n        self.scale = 1.0/4096.0\n\n    def _word_valid(self, w):\n        return (w >> 30) == 0b10 and ((w >> 14) & 0x3) == 0b01\n\n    def _sign13(self, v):\n        return ((v ^ 0x1000) - 0x1000)\n\n    def work(self, inp, out):\n        self.buf.extend(bytes(inp[0]))\n        produced = 0\n\n        # boucle tant qu’il y a au moins 4 octets\n        while len(self.buf) >= 4:\n            w = int.from_bytes(self.buf[:4], 'big')\n\n            if not self._word_valid(w):\n                # mauvais alignement : décale d’un octet\n                self.buf.pop(0)\n                continue\n\n            # mot OK : on le consomme\n            self.buf = self.buf[4:]\n\n            # I & Q (bit 0 masqué)\n            i = self._sign13(((w >> 16) & 0x3FFF) >> 1)\n            q = self._sign13(( w        & 0x3FFF) >> 1)\n\n            if produced < len(out[0]):\n                out[0][produced] = (i * self.scale) + 1j*(q * self.scale)\n                produced += 1\n            else:\n                break   # tampon sortie plein\n\n        return produced\n\n"
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "############################################################\n# udp_iq_vec_source_c  –  AT86RF215 → vecteurs complex64   #\n#  · 1 datagramme UDP  ⟶  1 vecteur de N samples           #\n#    N = (pkt_size - 8) / 4                                #\n############################################################\n#\n# @title      UDP IQ Vec Source\n# @category   Sources\n# @description\n#   Source UDP : transforme chaque datagramme IQ (format AT86RF215)\n#   en un vecteur de type complex64.\n#   La longueur du vecteur est fixée par pkt_size.\n#   Affiche également le nombre d'échantillons IQ reçus par seconde.\n#\n# @param port:int=5000                    # Port d’écoute UDP\n# @param pkt_size:int=1032                # chunk_bytes + 8 (doit vérifier (pkt_size-8)%4==0)\n# @param queue_len:int=4096               # Profondeur FIFO en vecteurs\n#\n############################################################\nimport socket, struct, threading, logging, numpy as np, queue, time\nfrom gnuradio import gr\n\n_HDR_SIZE   = 8                  # octets (sequence 64 bits)\n_SOCK_BUF   = 4 * 1024 * 1024    # 4 MiB – évite la perte en rafale\n\n\ndef _signed13_arr(u14: np.ndarray) -> np.ndarray:\n    \"\"\"uint16(14 b) ➜ int16(13 b) signé\"\"\"\n    s16       = (u14 >> 1).astype(np.int16)\n    neg_mask  = (s16 & 0x1000) != 0\n    s16[neg_mask] -= 1 << 13\n    return s16\n\n\nclass blk(gr.sync_block):\n    \"\"\"\n    UDP IQ vector source :\n        0 input  –  1 output : (complex64, vec_len)\n    \"\"\"\n    def __init__(self, port: int = 5000, pkt_size: int = 1032, queue_len: int = 4096):\n        if (pkt_size - _HDR_SIZE) % 4:\n            raise ValueError(\"pkt_size - 8 doit être un multiple de 4\")\n\n        self.port       = int(port)\n        self.pkt_size   = int(pkt_size)\n        self.vec_len    = (self.pkt_size - _HDR_SIZE) // 4\n        self._q         = queue.Queue(maxsize=int(queue_len))\n        self._seq       = None\n        self._evt       = threading.Event()\n        self._sock      = None\n        self._thr       = None\n\n        super().__init__(\"udp_iq_vec_source_c\",\n                         in_sig=None,\n                         out_sig=[(np.complex64, self.vec_len)])\n\n        logging.basicConfig(level=logging.INFO,\n                            format=\"%(levelname)s:%(name)s:%(message)s\")\n\n    # --------------------------------------------------------\n    def start(self):\n        self._sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)\n        self._sock.setsockopt(socket.SOL_SOCKET, socket.SO_RCVBUF, _SOCK_BUF)\n        self._sock.bind((\"\", self.port))\n        self._sock.settimeout(0.5)\n\n        self._evt.clear()\n        self._thr = threading.Thread(target=self._rx_loop, daemon=True)\n        self._thr.start()\n        logging.info(\"udp_iq_vec_source_c : écoute UDP %d (pkt=%d o, vec=%d)\",\n                     self.port, self.pkt_size, self.vec_len)\n        return super().start()\n\n    # --------------------------------------------------------\n    def stop(self):\n        self._evt.set()\n        if self._sock:\n            self._sock.close()\n        if self._thr and self._thr.is_alive():\n            self._thr.join(timeout=1.0)\n        return super().stop()\n\n    # --------------------------------------------------------\n    def _rx_loop(self):\n        hdr_size = _HDR_SIZE\n        vec_len  = self.vec_len\n        pkt_size = self.pkt_size\n\n        rate_t0    = time.time()\n        rate_count = 0\n\n        while not self._evt.is_set():\n            try:\n                dat, _ = self._sock.recvfrom(pkt_size)\n            except socket.timeout:\n                continue\n            except OSError:\n                break\n\n            if len(dat) != pkt_size:\n                logging.warning(\"paquet ignoré (%d o)\", len(dat))\n                continue\n\n            seq, = struct.unpack_from(\">Q\", dat, 0)\n            if self._seq is None:\n                self._seq = seq\n            elif seq != self._seq:\n                logging.warning(\"%d paquet(s) manqué(s) (att %d, reçu %d)\",\n                                seq - self._seq, self._seq, seq)\n            self._seq = (seq + 1) & 0xFFFFFFFFFFFFFFFF\n\n            # -------- Vectorisation NumPy --------\n            words = np.frombuffer(memoryview(dat)[hdr_size:],\n                                  dtype=\">u4\", count=vec_len)\n\n            i_raw = (words >> 16) & 0x3FFF     # 14 bits\n            q_raw =  words        & 0x3FFF\n\n            i = _signed13_arr(i_raw).astype(np.float32) / 4096.0\n            q = _signed13_arr(q_raw).astype(np.float32) / 4096.0\n\n            # -------- Compteur de débit IQ --------\n            rate_count += vec_len\n            now = time.time()\n            if now - rate_t0 >= 1.0:\n                logging.info(\"Débit RX : %d échantillons IQ/s\", rate_count)\n                rate_count = 0\n                rate_t0 = now\n\n            try:\n                self._q.put_nowait((i + 1j*q).astype(np.complex64))\n            except queue.Full:\n                logging.warning(\"FIFO pleine → vecteur perdu\")\n\n    # --------------------------------------------------------\n    def work(self, _, out_items):\n        out       = out_items[0]\n        produced  = 0\n        for k in range(len(out)):          # noutput_items en vecteurs\n            try:\n                vec = self._q.get_nowait()\n            except queue.Empty:\n                break\n            out[k][:] = vec                # copie directe\n            produced += 1\n        return produced                    # # de vecteurs écrits\n\n"
    pkt_size: chunk_bytes+8
    port: '5000'
    queue_len: '4096'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: "############################################################\n# rf215_cfg_sender – envoie une config uniforme « TXT »\n############################################################\nimport socket, textwrap\nfrom gnuradio import gr\nimport pmt  # port message fictif\n\nIP, PORT = \"10.42.0.78\", 6000\n\n\ndef ccf0_from_freq(f_hz):        # pas de 25 kHz\n    return int(round(f_hz / 25_000.0)) & 0xFFFF\n\n\ndef udp_send(payload: bytes, tag=\"\"):\n    print(f\"[rf215] >>> {tag} ({len(payload)} B)\", flush=True)\n    with socket.socket(socket.AF_INET, socket.SOCK_DGRAM) as s:\n        s.sendto(payload, (IP, PORT))\n\n\nclass blk(gr.basic_block):\n    \"\"\"\n    Envoie un fichier config TXT au daemon RF215 au démarrage,\n    puis 'STOP' à l'arrêt. 0 entrée, 0 sortie (port message fictif).\n    Paramètres :\n        cf           – fréquence centrale (Hz)     [default 868e6]\n        chunk        – taille bloc DMA/UDP (octets)[default 1024]\n        sr           – code SR (0-7) → f_s         [default 5 → 800 kS/s]\n        agc_on       – 1 = AGC auto, 0 = manuel    [default 0]\n        agc_target   – TGT (0-7)  –21…-42 dBFS     [default 4]\n        manual_gain  – GCW (0-23) pas de 3 dB      [default 17]\n    \"\"\"\n    def __init__(self,\n                 cf=868e6,\n                 chunk=1024,\n                 sr=5,\n                 agc_on=0,\n                 agc_target=4,\n                 manual_gain=17):\n\n        super().__init__(\"rf215_cfg_sender\", in_sig=None, out_sig=None)\n        self.cf          = float(cf)\n        self.chunk       = int(chunk)\n        self.sr          = int(sr) & 0x07\n        self.agc_on      = int(agc_on)\n        self.agc_target  = int(agc_target) & 0x07\n        self.manual_gain = int(manual_gain) & 0x1F\n\n        # port message bidon pour éviter le « pruning » GRC\n        self.message_port_register_out(pmt.intern(\"dummy\"))\n\n    # ------------------------------------------------------------\n    def start(self):\n        print(\"[rf215] start()\", flush=True)\n\n        # -----------------------------------------------------------------\n        # 1) Valeurs dérivées des paramètres\n        # -----------------------------------------------------------------\n        ccf0      = ccf0_from_freq(self.cf)\n        rxdfe_val = 0x80 | self.sr              # bit7=EN + SR[2:0]\n\n        # -----------------------------------------------------------------\n        # 2) Configuration AGC (0x010B / 0x010C)\n        # -----------------------------------------------------------------\n        if self.agc_on:\n            # AGC activé : EN=1, AVGS=1 (fenêtre 16 échantillons)\n            r09_agcc = 0x81                     # 0b0001 0001\n            rf09_agcs = (self.agc_target << 5)  # GCW ignoré par AGC\n            agc_desc = f\"AGC AUTO, target {self.agc_target}\"\n        else:\n            # AGC manuel : EN=0, gain fixe\n            r09_agcc = 0x00\n            rf09_agcs = (self.agc_target << 5) | self.manual_gain\n            agc_desc = (f\"AGC MANUAL, gain {self.manual_gain}\"\n                        f\", target bits {self.agc_target}\")\n\n        print(f\"[rf215] {agc_desc}\", flush=True)\n\n        # -----------------------------------------------------------------\n        # 3) Fichier configuration « TXT »\n        # -----------------------------------------------------------------\n        cfg_txt = textwrap.dedent(f\"\"\"\\\n            # Update from config_daemon\n            chunk_bytes={self.chunk}\n            IQIFC1=0x42\n            CS    =0x08\n            CCF0L =0x{ccf0 & 0xFF:02X}\n            CCF0H =0x{ccf0 >> 8:02X}\n            CNL   =0x00\n            CNM   =0x00\n            RXBWC =0x18\n            RXDFE =0x{rxdfe_val:02X}\n            R09_AGCC=0x{r09_agcc:02X}\n            RF09_AGCS=0x{rf09_agcs:02X}\n            \"\"\")\n\n        print(\"[rf215] -------- CONFIG --------\")\n        print(cfg_txt.strip())\n        print(\"--------------------------------\")\n\n        udp_send(cfg_txt.encode(), \"CFG\")\n        return super().start()\n\n    # ------------------------------------------------------------\n    def stop(self):\n        print(\"[rf215] stop()\", flush=True)\n        udp_send(b\"STOP\", \"STOP\")\n        return super().stop()\n\n    # (optionnel) évite les instanciations fantômes lors de la vérif GRC\n    def check_topology(self, nin, nout):\n        return nin == nout == 0\n\n"
    agc_on: AGC_on
    agc_target: AGC_target
    cf: 868e6
    chunk: chunk_bytes
    manual_gain: manual_gain
    sr: sample_rate_register_config
  states: {}
- name: fsk_demodulation_0
  id: fsk_demodulation
  parameters:
    crc_len: crc_len
    drate: data_rate
    fdev: fdev
    fsamp: samp_rate
    payload_len: payload_len
  states: {}
- name: fsk_onQuery_noise_estimation_0
  id: fsk_onQuery_noise_estimation
  parameters:
    n_est: '10'
    n_samples: '1024'
    query: noiseQuery
  states: {}
- name: fsk_packet_parser_0
  id: fsk_packet_parser
  parameters:
    address: '[0,0,1,1,1,1,1,0,0,0,1,0,1,0,1,0,0,1,0,1,0,1,0,0,1,0,1,1,0,1,1,1]'
    crc_len: crc_len
    hdr_len: hdr_len
    log_payload: Print_payload
    payload_len: payload_len
  states: {}
- name: fsk_preamble_detect_0
  id: fsk_preamble_detect
  parameters:
    drate: data_rate
    enable: Enable_detection
    fdev: fdev
    fsamp: samp_rate
    packet_len: packet_len
    threshold: detect_threshold_entry
  states: {}
- name: fsk_synchronization_0
  id: fsk_synchronization
  parameters:
    drate: data_rate
    enable_log: Print_metrics
    fdev: fdev
    fsamp: samp_rate
    hdr_len: hdr_len
    packet_len: packet_len
    tx_power: tx_power
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 62.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: data_rate*1
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '1'
    ipv6: 'False'
    maxoutbuf: '1024'
    minoutbuf: '256'
    notify_missed: 'True'
    payloadsize: chunk_bytes+8
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: SDR signal
    rate: '30'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    rate: '30'
    type: complex
  states: {state: disabled}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      import socket, textwrap, atexit
      from gnuradio import gr, eng_notation as e

      # ---------- récupère directement les variables GRC ----------
      try:
          center_freq_hz_val = float(center_freq_hz)   # déjà défini par GRC
          chunk_bytes_val    = int(chunk_bytes)
      except NameError:
          # Valeurs de secours si on lance le fichier .py à la main
          center_freq_hz_val = 868.3e6
          chunk_bytes_val    = 8192
      # ------------------------------------------------------------

      HPS_IP   = "10.42.0.78"
      CFG_PORT = 6000

      def ccf0_from_freq(freq):
          return int(round(freq/25_000.0)) & 0xFFFF

      def build_config_txt(freq_hz, chunk):
          ccf0 = ccf0_from_freq(freq_hz)
          return textwrap.dedent(f"""\
              chunk_bytes={chunk}
              IQIFC1=0x42
              CS    =0x08
              CCF0L =0x{ccf0 & 0xFF:02X}
              CCF0H =0x{(ccf0>>8) & 0xFF:02X}
              CNL   =0x00
              CNM   =0x00
              RXBWC =0x18
              RXDFE =0x83
              AGCC  =0xFF
              """)

      def udp_send(payload: bytes):
          sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
          sock.sendto(payload, (HPS_IP, CFG_PORT))
          sock.close()

      # ---- init : envoi config & démarrage du flux ---------------
      udp_send(build_config_txt(center_freq_hz_val, chunk_bytes_val).encode())

      # ---- à la fermeture : STOP ---------------------------------
      atexit.register(lambda: udp_send(b"STOP"))

      # ---- bloc « dummy » sans ports I/O --------------------------
      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="rf215_cfg_sender",
                                      in_sig=None, out_sig=None)
    section: main_after_init
  states: {state: disabled}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:10000
    timeout: '100'
    type: byte
    vlen: payload_len
  states: {}

connections:
- [blocks_throttle2_0, '0', dc_blocker_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_vector_to_stream_1_1, '0', blocks_throttle2_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [epy_block_2, '0', blocks_throttle2_0, '0']
- [epy_block_6, '0', blocks_vector_to_stream_1_1, '0']
- [epy_block_7, dummy, blocks_message_strobe_0, set_msg]
- [fsk_demodulation_0, '0', fsk_packet_parser_0, '0']
- [fsk_onQuery_noise_estimation_0, NoisePow, fsk_synchronization_0, NoisePow]
- [fsk_packet_parser_0, '0', zeromq_pub_sink_0, '0']
- [fsk_preamble_detect_0, '0', fsk_synchronization_0, '0']
- [fsk_synchronization_0, '0', fsk_demodulation_0, '0']
- [low_pass_filter_0, '0', fsk_onQuery_noise_estimation_0, '0']
- [low_pass_filter_0, '0', fsk_preamble_detect_0, '0']
- [network_udp_source_0, '0', epy_block_0, '0']
- [network_udp_source_0, '0', epy_block_1, '0']
- [network_udp_source_0, '0', epy_block_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
